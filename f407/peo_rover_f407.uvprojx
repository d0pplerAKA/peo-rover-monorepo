# Keil uVision project peo_rover_f407.uvprojx, settings and files
target proj (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: peo_rover_f407
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_HSE_BYPASS,__CC_ARM,ARM_MATH_CM4,__FPU_PRESENT,__FPU_USED,EMPL_TARGET_STM32F4,EMPL,MPU6050,USE_DMP,MPL_LOG_NDEBUG=1
  c include: ..\peo_rover;.\STARTUP;.\CMSIS;.\FWLIB\inc;.\FWLIB\src;.\COMPONENTS;.\COMPONENTS\VL53L1X\core;.\COMPONENTS\VL53L1X\platform;.\COMPONENTS\motion_driver_dmp;.\COMPONENTS\motion_driver_dmp\driver;.\COMPONENTS\motion_driver_dmp\driver\eMPL;.\COMPONENTS\motion_driver_dmp\driver\include;.\COMPONENTS\motion_driver_dmp\driver\stm32L;.\COMPONENTS\motion_driver_dmp\eMPL-hal;.\COMPONENTS\motion_driver_dmp\mllite;.\COMPONENTS\motion_driver_dmp\mpl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/: arm_cortexM4lf_math.lib arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group STARTUP
    ./STARTUP/: startup_stm32f40xx.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group COMPONENTS
    ./COMPONENTS/CONTROL/: control.c
    ./COMPONENTS/DELAY/: delay.c
    ./COMPONENTS/ENCODER/: encoder.c
    ./COMPONENTS/I2C/: i2c_mpu.c i2c_vl.c i2c_ina.c
    ./COMPONENTS/MOTOR/: motor.c
    ./COMPONENTS/SENSOR_HUB/: sensor_hub.c
    ./COMPONENTS/TFT_SPI/: tft_spi.c
    ./COMPONENTS/TFT_UI/: tft_ui.c
    ./COMPONENTS/BUILTIN_LED/: builtin_led.c
    ./COMPONENTS/INA3221/: ina3221.c
    ./COMPONENTS/MPU6050/: mpu6050.c
    ./COMPONENTS/NVIC/: nvic.c
    ./COMPONENTS/RCC/: rcc.c
    ./COMPONENTS/TIMER/: timer.c
    ./COMPONENTS/TOF400C/: tof400c.c
    ./COMPONENTS/USART/: usart_dbg.c
    ./COMPONENTS/ESP_LINK/: esp_link.c
    ./COMPONENTS/GAMEPAD/: gamepad.c
    ./COMPONENTS/VL53L1X/core/: VL53L1X_api.c VL53L1X_calibration.c
    ./COMPONENTS/VL53L1X/platform/: vl53l1_platform.c
  group motion_dmp_driver
    ./COMPONENTS/motion_driver_dmp/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./COMPONENTS/motion_driver_dmp/eMPL-hal/: eMPL_outputs.c
    ./COMPONENTS/motion_driver_dmp/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./COMPONENTS/motion_driver_dmp/mpl/: libmpllib.lib
    ./COMPONENTS/motion_driver_dmp/driver/include/: log.h mlinclude.h mlmath.h mlos.h mltypes.h mpu.h stdint_invensense.h
  group USER
    ./: main.c
